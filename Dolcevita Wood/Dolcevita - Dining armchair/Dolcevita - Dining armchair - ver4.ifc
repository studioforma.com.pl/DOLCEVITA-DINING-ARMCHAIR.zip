Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Dolcevita - Dining armchair - ver4.ifc
Time: 2024-01-11T14:34:19
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (23)
Name
 | Dolcevita - Dining armchair model_16 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_17 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_18 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_19 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_20 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_21 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_0 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_1 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_2 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_3 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_4 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_5 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_6 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_7 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_22 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_8 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_9 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_10 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_11 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_12 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_13 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_14 - ObjectType: SketchupGroup
 | Dolcevita - Dining armchair model_15 - ObjectType: SketchupGroup
